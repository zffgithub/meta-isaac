inherit fix-isaac

ROS_BUILD_DEPENDS += " \
    nlohmann-json \
"

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-adapter-native \
"