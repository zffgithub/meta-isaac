inherit fix-isaac